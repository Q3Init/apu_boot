# Keil uVision project apu_boot.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: APM32E103VE Geehy
  pack: Geehy.APM32E1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: apu_boot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: APM32E103_MIN,EASY_OS
  c include: ..\inc;..\..\os\easyos\OS_Driver;..\..\os\easyos\OS_Task;..\..\types;..\..\lib\chip_libraries\APM32E103VE\drivers\inc;..\..\lib\chip_libraries\APM32E103VE\cmsis\cm3\core_support;..\..\lib\chip_libraries\APM32E103VE\cmsis\cm3\device_support;..\..\config\chip_int-cfg\APM32E103VE\inc;..\..\config\os-cfg\easyos-cfg\inc;..\..\platform\bootcheck\inc;..\..\platform\iap\inc;..\..\platform\intertp\inc;..\..\platform\pdur\inc;..\..\platform\uartif\inc;..\..\config\platform-cfg\bootcheck\inc;..\..\config\platform-cfg\iap\inc;..\..\config\platform-cfg\intertp\inc;..\..\config\platform-cfg\pdur\inc;..\..\config\platform-cfg\uartif\inc;..\..\drivers\crc\inc;..\..\drivers\flash\inc;..\..\drivers\gpio\inc;..\..\drivers\uart\inc;..\..\drivers\include;..\..\config\driver-cfg\flash\inc;..\..\config\driver-cfg\gpio\inc;..\..\config\driver-cfg\uart\inc;..\..\drivers\clock\inc;..\..\config\driver-cfg\clock\inc;..\..\config\driver-cfg\dma\inc;..\..\drivers\dma\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group config
    ../../config/chip_int-cfg/APM32E103VE/src/: apm32e10x_int.c
    ../../config/os-cfg/easyos-cfg/src/: easyos_cfg.c
    ../../config/platform-cfg/bootcheck/src/: bootcheck_cfg.c
    ../../config/platform-cfg/iap/src/: iap_cfg.c
    ../../config/platform-cfg/intertp/src/: intertp_cfg.c
    ../../config/platform-cfg/pdur/src/: pdur_cfg.c
    ../../config/platform-cfg/uartif/src/: uartif_cfg.c
    ../../config/driver-cfg/flash/src/: flash_cfg.c
    ../../config/driver-cfg/gpio/src/: gpio_cfg.c
    ../../config/driver-cfg/uart/src/: uart_cfg.c
    ../../config/driver-cfg/dma/src/: dma_cfg.c
    ../../config/driver-cfg/clock/src/: clock_cfg.c
  group drivers
    ../../drivers/crc/src/: crc.c
    ../../drivers/flash/src/: flash.c
    ../../drivers/gpio/src/: gpio.c
    ../../drivers/uart/src/: uart.c
    ../../drivers/clock/src/: clock.c
    ../../drivers/dma/src/: dma.c
  group apm32e103vet6
    ../../drivers/dma/src/: apm32e103vet6_dma.c
    ../../drivers/flash/src/: apm32e103vet6_flash.c
    ../../drivers/gpio/src/: apm32e103vet6_gpio.c
    ../../drivers/uart/src/: apm32e103vet6_uart.c
    ../../drivers/clock/src/: apm32e103vet6_clock.c
  group lib
    ../../lib/chip_libraries/APM32E103VE/drivers/src/: apm32e10x_adc.c apm32e10x_bakpr.c apm32e10x_can.c apm32e10x_crc.c apm32e10x_dac.c apm32e10x_dbgmcu.c apm32e10x_dma.c apm32e10x_dmc.c apm32e10x_eint.c apm32e10x_fmc.c apm32e10x_gpio.c apm32e10x_i2c.c apm32e10x_iwdt.c apm32e10x_misc.c apm32e10x_pmu.c apm32e10x_rcm.c apm32e10x_rtc.c apm32e10x_sci2c.c apm32e10x_sdio.c apm32e10x_smc.c apm32e10x_spi.c apm32e10x_tmr.c apm32e10x_usart.c apm32e10x_usb.c apm32e10x_wwdt.c
    ../../lib/chip_libraries/APM32E103VE/cmsis/cm3/device_support/: system_apm32e10x.c
    ../../lib/chip_libraries/APM32E103VE/cmsis/cm3/device_support/startup/mdk/: startup_apm32e10x_hd.s
  group os
    ../../os/easyos/OS_Driver/: Os_BaseTimer.c Os_EvtHdl.c Os_TimerHdl.c
    ../../os/easyos/OS_Task/: Os_TaskHdl_Lv0.c Os_TaskHdl_Lv1.c Os_TaskHdl_Lv2.c
  group platform
    ../../platform/bootcheck/src/: bootcheck.c
    ../../platform/iap/src/: iap.c
    ../../platform/intertp/src/: intertp.c
    ../../platform/pdur/src/: pdur.c
    ../../platform/uartif/src/: uartif.c
  group project
    ../src/: easyos_task.c main.c rte.c
